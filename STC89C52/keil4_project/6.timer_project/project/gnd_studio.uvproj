# Keil uVision project gnd_studio.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: gnd_studio +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\main;..\user_lib\delay;..\user_lib\led;..\user_lib\timer
  group main
    ../main/: main.c
  group user_lib
    ../user_lib/delay/: delay.c
    ../user_lib/led/: led.c
    ../user_lib/timer/: timer.c
