# Keil uVision project gnd_studio.uvproj, settings and files
target gnd_studio (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: gnd_studio
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\firmware_lib\inc;..\system\inc;..\user_lib\delay;..\user_lib\spi;..\user_lib\usart;..\user_lib\w25qxx
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ../main/: main.c
  group firmware_lib
    ../firmware_lib/src/: stm32f10x_gpio.c misc.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c
  group start_up
    ../start_up/: core_cm3.c startup_stm32f10x_md.s
  group system
    ../system/src/: stm32f10x_it.c system_stm32f10x.c
  group user_lib
    ../user_lib/delay/: delay.c
    ../user_lib/spi/: spi.c
    ../user_lib/usart/: usart.c
    ../user_lib/w25qxx/: w25qxx.c
